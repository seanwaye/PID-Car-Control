# Keil uVision project main_controller.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: controller +hex
  c flags: Optim=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\User;..\platform;..\Motor;..\IMU;..\STM32F10x_StdPeriph_Driver\inc;..\PID_Controller
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s
  group STM32F1Lib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c
  group USER
    ../User/: main.c
  group Platform
    ../platform/: port.c
    ../Platform/: system_stm32f10x.c stm32f10x_it.c
  group Motor
    ../Motor/: basic_movement.c pwm.c encoder.c
  group IMU
    ../IMU/: JY901.c usart_imu.c
  group PID Controller
    ../PID_Controller/: MotorControl.c
