# Keil uVision project ANO_Remoter.uvproj, settings and files
target ANO_Remoter_V2.0 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ANO_USB +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: .\ANO_Remoter;.\Driver;.\STM32_LIB\CMSIS;.\USB_hid;.\USB_library;.\STM32_LIB\LIB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group ANO_Remoter
    ./ANO_Remoter/: main.c sysconfig.h ANO_Scheduler.c ANO_Scheduler.h ANO_Display.c ANO_Display.h ANO_Stick.c ANO_Stick.h ANO_DT.c ANO_DT.h ANO_Param.c ANO_Param.h
  group Driver
    ./Driver/: board.c board.h stm32f10x_it.c stm32f10x_it.h ANO_Drv_LED.c ANO_Drv_LED.h ANO_Drv_Nrf24l01.c ANO_Drv_Nrf24l01.h ANO_Drv_SPI.c ANO_Drv_SPI.h ANO_Drv_Uart.c ANO_Drv_Uart.h ANO_Drv_ADC.c ANO_Drv_ADC.h ANO_Drv_Oled.c ANO_Drv_Oled.h ANO_Drv_Oled_font.h ANO_Drv_I2C.c ANO_Drv_I2C.h ANO_Drv_MPU6050.c ANO_Drv_MPU6050.h ANO_Drv_Hid.c ANO_Drv_Hid.h ANO_Drv_Flash.c ANO_Drv_Flash.h
  group STM32_LIB
    ./STM32_LIB/CMSIS/: startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c core_cm3.c
    ./STM32_LIB/LIB/src/: stm32f10x_rcc.c misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
    ./STM32_LIB/LIB/inc/: stm32f10x_conf.h
  group USB_lib
    ./USB_library/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USB_hid
    ./USB_hid/: usb_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group doc
    ./: readme.txt
